# Keil uVision project IOTKit_CM33_s.uvprojx, settings and files
target FVP (6220000::V6.22::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: IOTKit_CM33_s
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
  group Source Group 1
    ./: main_s.c stdout_USART.c mtb.c Secure_Functions.c cfa.c
  group Documentation
    ../: README.md
target V2M-MPS2+ (6220000::V6.22::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.2
  cpu: as above
  output: IOTKit_CM33_s
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
software components: CMSIS:CORE 6.1.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:USART 1.0.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.2.0
